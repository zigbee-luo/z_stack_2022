# IAR project zed_doorlockcontroller_CC1352P_2_LAUNCHXL_tirtos_iar.ewp, settings and files
configuration default (ARM)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  group (top)
    ./: zed_doorlockcontroller_CC1352P_2_LAUNCHXL_tirtos_iar.ipcf SysConfig_Generated_Files.ipcf app.cfg

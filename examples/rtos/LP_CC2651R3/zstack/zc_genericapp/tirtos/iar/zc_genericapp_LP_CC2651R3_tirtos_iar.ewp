# IAR project zc_genericapp_LP_CC2651R3_tirtos_iar.ewp, settings and files
configuration default (ARM)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  group (top)
    ./: zc_genericapp_LP_CC2651R3_tirtos_iar.ipcf SysConfig_Generated_Files.ipcf app.cfg
